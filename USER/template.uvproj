# Keil uVision project template.uvproj, settings and files
target TEMPLATE (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5_HMI_V1.0 +hex
  c flags: Optimize=3
  c include: ..\USER;..\FUNC_HANDLER;..\GUI_APP;..\HANDWARE\NOR_FLASH;..\HANDWARE\USART;..\T5LDriver
  link misc: REMOVEUNUSED
  group USER
    ./: STARTUP_M5.A51 main.c Task_manager.c
    ../FUNC_HANDLER/: rtu_process.c
  group GUI_APP
    ../GUI_APP/: start_win.c
  group FUNC_HANDLER
    ../FUNC_HANDLER/: motor_cmd.c func_handler.c rtu_protocol.c crc_calc16.c rtu_api.c
  group HANDWARE
    ./: sys.c
    ../HANDWARE/NOR_FLASH/: nor_flash.c
    ../HANDWARE/USART/: usart.c
  group T5LDriver
    ../T5LDriver/: T5LDriver.C T5LUart4.c
